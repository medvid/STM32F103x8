<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Ex00-Template\IAR\Ex00-Template.ewp</path>
  </project>
  <batchBuild/>
</workspace>


